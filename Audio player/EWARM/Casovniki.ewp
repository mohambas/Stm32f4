# IAR project Casovniki.ewp, settings and files
configuration Casovniki (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery; ..\tm_stm32f4_fatfs; ..\tm_stm32f4_fatfs\fatfs; ..\tm_stm32f4_fatfs\fatfs\drivers; ..\tm_stm32f4_fatfs\fatfs\option
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IO_Toggle.srec
  ILINK.IlinkOutputFile: IO_Toggle.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group SDCARD
    ../tm_stm32f4_fatfs/: defines.h tm_stm32f4_delay.c tm_stm32f4_delay.h tm_stm32f4_fatfs.c tm_stm32f4_fatfs.h tm_stm32f4_spi.c tm_stm32f4_spi.h
    ../tm_stm32f4_fatfs/fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../tm_stm32f4_fatfs/fatfs/drivers/: fatfs_sd.c fatfs_sd.h
    ../tm_stm32f4_fatfs/fatfs/option/: syscall.c unicode.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
    ../../../Peripheral_Examples/IO_Toggle/: system_stm32f4xx.c
  group User
    ../: codec.c codec.h crystalLcd.c crystalLcd.h keypad.c keypad.h main.c main.h stm32f4xx_it.c vars.h
